v {xschem version=3.4.8RC file_version=1.3}
G { 570 -450 }
C {devices/ammeter.sym} 570 -450 0 0 {name=Vid savecurrent=true spice_ignore=0}
